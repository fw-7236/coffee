# Keil uVision project CRM1227.uvproj, settings and files
target Target 1 (MCS-51)
  device: OB38R08T1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xAF) CLOCK(16000000)
  output: CRM1227 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_OB38R08T1.A51 ADC.c EEPROM.c Main.c Timer.c WDT.c
