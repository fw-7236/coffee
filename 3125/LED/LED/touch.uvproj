# Keil uVision project touch.uvproj, settings and files
target Target 1 (MCS-51)
  device: OB38R08T1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xAF) CLOCK(16000000)
  output: touch +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./user/: Main.c InitROM.asm UART0.c ADC.c Timer.c EEPROM.c
