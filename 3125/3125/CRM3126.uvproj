# Keil uVision project CRM3126.uvproj, settings and files
target Target 1 (MCS-51)
  device: OB38R08T1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xAF) CLOCK(16000000)
  output: CRM3126 +hex
  c flags: Optimize=1
  c include: ..\3126
  group CODE
    ./: STARTUP_OB38R08T1.A51 main.c WDT.c UART0.c Timer.c ADC.c
